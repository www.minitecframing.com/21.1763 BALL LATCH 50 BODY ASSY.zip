# Autodesk Inventor assembly: 21.1763 BALL LATCH 50
## iProperties
Created: 2007-03
Part Number: 21.1763 BALL LATCH 50
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
